# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, LFS_CONFIG=lfs_config.h, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: board;rt-thread\components\drivers\include;applications\lhc_modbus;packages\quick_led-latest\inc;board\CubeMX_Config\Core\Inc;applications\lhc_lora;rt-thread\components\drivers\usb\usbdevice;packages\minIni-latest\dev;rt-thread\components\dfs\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\utilities\ulog;packages\ota_downloader-latest;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\stdio;applications;rt-thread\libcpu\arm\cortex-m3;applications\lhc_dwin;libraries\HAL_Drivers;rt-thread\components\finsh;applications\lhc_module;packages\Qfplib_M3-latest;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;applications\lhc_tools;rt-thread\components\drivers\include;packages\littlefs-latest;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;rt-thread\components\utilities\ymodem;libraries\HAL_Drivers\CMSIS\Include;packages\CmBacktrace-v1.4.1;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\components\net\at\include;libraries\HAL_Drivers\drv_flash;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;.;rt-thread\components\libc\compilers\common\include;rt-thread\include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;rt-thread\components\fal\inc;libraries\HAL_Drivers\config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: user_climate.c user_at.c user_water_room.c main.c user_photosynthesis.c user_file.c
  group AT
    rt-thread/components/net/at/src/: at_client.c at_utils.c at_cli.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cmb_flash_log.c cm_backtrace.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/CubeMX_Config/Core/Src/: main.c stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f1.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group lhc_dwin
    applications/lhc_dwin/: lhc_dwin.c lhc_dwin_port.c
  group lhc_lora
    applications/lhc_lora/: lhc_lora.c
  group lhc_modbus
    applications/lhc_modbus/: lhc_modbus.c lhc_modbus_port.c
  group lhc_module
    applications/lhc_module/: lhc_extern_io.c
  group lhc_tools
    applications/lhc_tools/: lhc_tool.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_crc.c stm32f1xx_ll_usb.c stm32f1xx_hal_cec.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_nor.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_pcd.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_hcd.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs_crc.c lfs.c lfs_util.c
  group minIni
    packages/minIni-latest/dev/: minIni.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group quick_led
    packages/quick_led-latest/src/: qled.c qled_sample.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
